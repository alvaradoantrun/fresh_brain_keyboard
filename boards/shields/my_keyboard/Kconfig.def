## boards/shields/my_keyboard/Kconfig.def
```kconfig
if SHIELD_MY_KEYBOARD
source "boards/shields/my_keyboard/my_keyboard.conf"
endif
```
